# Keil uVision project Cosmonaut.uvproj, settings and files
target BulletHell (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Cosmonaut
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib\rvmdk;..\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s actor.c graphics.c sound.c SysTick.c Cosmonaut.c utils.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
  group Drivers
    ./: draw.c rit128x96x4.c controller.c dac.c adc.c
