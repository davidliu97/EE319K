# Keil uVision project Lab 9.uvproj, settings and files
target Lab9 (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab9
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s Output.c Lab9.c UART1.c adc.c SysTick.c queue.c LCD.s
  group Library
    ../driverlib/rvmdk/: driverlib.lib
    ./: rit128x96x4.c
